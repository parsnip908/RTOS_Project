# Keil uVision project User.uvprojx, settings and files
target User (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: User
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --split --edit=import.stf --diag_warning L6238E
  group Source
    ./: startup.s osasm.s Display.s User.c
  group Symbols
    ../RTOS_Lab5_ProcessLoader/: Lab5.def
software components: CMSIS:CORE 5.6.0
